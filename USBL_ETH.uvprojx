# Keil uVision project USBL_ETH.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H743ZITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: USBL_ETH
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32H743ZITx/STCubeGenerated/Src/: main.c stm32h7xx_it.c
    ./RTE/Device/STM32H743ZITx/STCubeGenerated/Inc/: stm32h7xx_it.h
software components: CMSIS:CORE 5.1.1, CMSIS:DSP 1.5.2, CMSIS:RTOS2:Keil RTX5 5.3.0, Network:CORE 7.8.0, Network:Interface:ETH 7.8.0, Network:Socket:UDP 7.8.0, CMSIS Driver:Ethernet MAC 1.0.0, CMSIS Driver:Ethernet PHY:LAN8742A 1.2.0, Device:STM32Cube HAL:Common 1.1.0, Device:STM32Cube HAL:Cortex 1.2.0, Device:STM32Cube HAL:DMA 1.2.0, Device:STM32Cube HAL:ETH 1.2.0, Device:STM32Cube HAL:GPIO 1.2.0, Device:STM32Cube HAL:MDMA 1.2.0, Device:STM32Cube HAL:PWR 1.2.0, Device:STM32Cube HAL:QSPI 1.2.0, Device:STM32Cube HAL:RCC 1.2.0, Device:STM32Cube HAL:TIM 1.2.0, Device:STM32Cube HAL:UART 1.2.0, Device:Startup 1.2.0
